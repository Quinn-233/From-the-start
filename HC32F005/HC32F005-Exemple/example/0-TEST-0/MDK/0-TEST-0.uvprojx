# Keil uVision project 0-TEST-0.uvprojx, settings and files
target template_Release (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 0-TEST-0 +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ../../../mcu/common/: system_hc32f005.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: adc.c adt.c bt.c crc.c flash.c i2c.c lpm.c lvd.c pca.c reset.c spi.c trim.c uart.c vc.c wdt.c clk.c ddl.c gpio.c interrupts_hc32f005.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
