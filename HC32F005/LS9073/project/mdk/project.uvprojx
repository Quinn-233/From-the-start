# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\mcu\common;..\..\stdperiph_driver\inc;..\include;..\bsp
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group user
    ../: main.c light_vm.c light_effects.c light_event.c light_sdata.c
  group bsp
    ../bsp/: systick.c malloc.c string_lights.c key.c com.c disk.c
  group common
    ./: startup_hc32f005.s
    ../../mcu/common/: system_hc32f005.c
  group stdperiph_driver
    ../../stdperiph_driver/src/: ddl.c interrupts_hc32f005.c clk.c gpio.c uart.c bt.c flash.c
software components: CMSIS:CORE 5.1.2
